# Keil uVision project V2.0_STC8G.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: V2.0_STC8G
  c flags: Optimize=8 SizeSpeed=1
  group STD_Driver
    ./STD_Driver/: STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_UART.c
